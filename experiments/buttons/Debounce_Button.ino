const int BUTTON_PIN = 2;
const int LED_PIN = LED_BUILTIN;

const int DEBOUNCE_DELAY = 50;


int buttonState = 0;
int prevButtonState = 0;
int ledValue = 0;
int counter = 0;
int lastDebounceTime = 0;

void setup() {
  pinMode(BUTTON_PIN, INPUT_PULLUP);
  pinMode(LED_PIN, OUTPUT);
  Serial.begin(9600);
}

void loop() {
  int reading = digitalRead(BUTTON_PIN);
  
  if (reading != prevButtonState) {
    lastDebounceTime = millis();
  }
  
  if (millis() - lastDebounceTime > DEBOUNCE_DELAY) {
    if (reading != buttonState) {
      buttonState = reading;
      if (buttonState == LOW) {
        ledValue = !ledValue;
      }
    }
  }
  
  digitalWrite(LED_PIN, ledValue);
  previButtonState = reading;
}
